* /home/ash98/Downloads/eSim-master/src/SubcircuitLibrary/LM_353/LM_353.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Sun Dec 29 18:44:34 2019

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ eSim_PJF
J2  Net-_J1-Pad1_ Net-_J2-Pad2_ Net-_J1-Pad3_ eSim_PJF
Q2  Net-_J1-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad1_ eSim_PNP
Q4  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_J1-Pad3_ eSim_PNP
J3  Net-_J1-Pad3_ ? Net-_J3-Pad3_ eSim_PJF
Q3  Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad3_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_Q1-Pad2_ Net-_C1-Pad1_ eSim_NPN
R3  Net-_J1-Pad3_ Net-_C1-Pad1_ 1.8k
Q5  Net-_Q1-Pad2_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
R1  Net-_Q1-Pad1_ Net-_R1-Pad2_ 2k
R4  Net-_Q6-Pad1_ Net-_R4-Pad2_ 2k
R2  Net-_R1-Pad2_ Net-_D2-Pad2_ 100
R5  Net-_R4-Pad2_ Net-_D2-Pad2_ 100
Q8  Net-_Q13-Pad2_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
Q7  Net-_J1-Pad3_ Net-_C1-Pad1_ Net-_Q13-Pad2_ eSim_NPN
U2  Net-_D2-Pad2_ Net-_J3-Pad3_ zener
Q12  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_J1-Pad3_ eSim_PNP
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q11  Net-_Q11-Pad1_ Net-_J3-Pad3_ Net-_D1-Pad1_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_NPN
R6  Net-_D1-Pad2_ Net-_D2-Pad1_ 20k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q9  Net-_D2-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad1_ eSim_PNP
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
Q16  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q14-Pad2_ eSim_NPN
Q14  Net-_Q11-Pad1_ Net-_Q14-Pad2_ Net-_C1-Pad2_ eSim_NPN
R8  Net-_Q14-Pad2_ Net-_C1-Pad2_ 6k
Q13  Net-_C1-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
R7  Net-_Q13-Pad3_ Net-_D2-Pad2_ 30
Q19  ? Net-_Q11-Pad1_ Net-_Q18-Pad2_ eSim_NPN
Q18  Net-_Q11-Pad1_ Net-_Q18-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R10  Net-_Q18-Pad2_ Net-_Q17-Pad3_ 22
R11  Net-_Q17-Pad3_ Net-_Q17-Pad2_ 30
Q17  Net-_D3-Pad1_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_PNP
Q20  Net-_D2-Pad2_ Net-_C1-Pad2_ Net-_Q17-Pad2_ eSim_PNP
D3  Net-_D3-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q15  Net-_C1-Pad1_ Net-_D3-Pad1_ Net-_Q15-Pad3_ eSim_NPN
R9  Net-_Q15-Pad3_ Net-_D2-Pad2_ 160
U1  Net-_J1-Pad2_ Net-_J2-Pad2_ Net-_Q17-Pad3_ Net-_J1-Pad3_ Net-_D2-Pad2_ PORT

.end
