* /home/ash98/Downloads/eSim-master/src/SubcircuitLibrary/LM_358/LM_358.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Sun Dec 29 19:55:06 2019

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ eSim_PNP
Q4  Net-_C2-Pad2_ Net-_Q4-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q1  GND /Inv Net-_Q1-Pad3_ eSim_PNP
Q6  GND /Non-Inv Net-_Q4-Pad2_ eSim_PNP
Q5  Net-_C2-Pad2_ Net-_Q2-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_C2-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_Q11-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
Q8  Net-_Q11-Pad1_ Net-_Q7-Pad3_ Net-_Q8-Pad3_ eSim_NPN
Q9  Net-_C2-Pad1_ Net-_Q8-Pad3_ Net-_Q13-Pad1_ eSim_NPN
Q10  Net-_C2-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R2  Net-_Q10-Pad2_ Net-_Q10-Pad3_ 30
Q13  Net-_Q13-Pad1_ Net-_C2-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q7  Net-_Q13-Pad1_ Net-_C2-Pad2_ Net-_Q7-Pad3_ eSim_PNP
R1  Net-_Q8-Pad3_ Net-_Q13-Pad1_ 10k
Q16  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_PNP
Q17  Net-_C1-Pad2_ Net-_Q17-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q14  GND /Inv Net-_Q14-Pad3_ eSim_PNP
Q19  GND /Non-Inv Net-_Q17-Pad2_ eSim_PNP
Q18  Net-_C1-Pad2_ Net-_Q15-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q24  Net-_Q11-Pad1_ Net-_C1-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q25  Net-_Q11-Pad1_ Net-_Q24-Pad3_ Net-_Q23-Pad2_ eSim_NPN
Q21  Net-_Q11-Pad1_ Net-_Q20-Pad3_ Net-_Q21-Pad3_ eSim_NPN
Q22  Net-_C1-Pad1_ Net-_Q21-Pad3_ Net-_Q13-Pad1_ eSim_NPN
Q23  Net-_C1-Pad1_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
R4  Net-_Q23-Pad2_ Net-_Q23-Pad3_ 30
Q26  Net-_Q13-Pad1_ Net-_C1-Pad1_ Net-_Q23-Pad3_ eSim_PNP
Q20  Net-_Q13-Pad1_ Net-_C1-Pad2_ Net-_Q20-Pad3_ eSim_PNP
R3  Net-_Q21-Pad3_ Net-_Q13-Pad1_ 10k
U1  Net-_Q10-Pad2_ /Inv /Non-Inv Net-_Q13-Pad1_ ? /Inv Net-_Q23-Pad2_ Net-_Q11-Pad1_ PORT
R6  Net-_Q11-Pad1_ Net-_Q2-Pad3_ 2500k
R8  Net-_Q11-Pad1_ Net-_Q7-Pad3_ 3750k
R10  Net-_Q11-Pad1_ Net-_C2-Pad1_ 1500k
R11  Net-_Q23-Pad2_ Net-_Q13-Pad1_ 1500k
R12  Net-_Q10-Pad2_ Net-_Q13-Pad1_ 1500k
R5  Net-_Q11-Pad1_ Net-_Q15-Pad3_ 2500k
R7  Net-_Q11-Pad1_ Net-_Q20-Pad3_ 3750k
R9  Net-_Q11-Pad1_ Net-_C1-Pad1_ 1500k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 100p
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 100p

.end
