* /home/ash98/Downloads/eSim-master/src/SubcircuitLibrary/LM_7404/LM_7404.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Sun Dec 29 22:20:02 2019

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ adc_bridge_1
U6  Net-_U2-Pad2_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_M1-Pad1_ dac_bridge_1
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
U3  Net-_U1-Pad3_ Net-_U3-Pad2_ adc_bridge_1
U7  Net-_U3-Pad2_ Net-_U11-Pad1_ d_inverter
U11  Net-_U11-Pad1_ Net-_M2-Pad1_ dac_bridge_1
M2  Net-_M2-Pad1_ Net-_M1-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ eSim_MOS_N
U4  Net-_U1-Pad5_ Net-_U4-Pad2_ adc_bridge_1
U8  Net-_U4-Pad2_ Net-_U12-Pad1_ d_inverter
U12  Net-_U12-Pad1_ Net-_M3-Pad1_ dac_bridge_1
M3  Net-_M3-Pad1_ Net-_M1-Pad2_ Net-_M3-Pad3_ Net-_M3-Pad3_ eSim_MOS_N
U5  Net-_U1-Pad9_ Net-_U5-Pad2_ adc_bridge_1
U9  Net-_U5-Pad2_ Net-_U13-Pad1_ d_inverter
U13  Net-_U13-Pad1_ Net-_M4-Pad1_ dac_bridge_1
M4  Net-_M4-Pad1_ Net-_M1-Pad2_ Net-_M4-Pad3_ Net-_M4-Pad3_ eSim_MOS_N
U1  Net-_U1-Pad1_ Net-_M1-Pad3_ Net-_U1-Pad3_ Net-_M2-Pad3_ Net-_U1-Pad5_ Net-_M3-Pad3_ GND Net-_M4-Pad3_ Net-_U1-Pad9_ Net-_M5-Pad3_ Net-_U1-Pad11_ Net-_M6-Pad3_ Net-_U1-Pad13_ Net-_M1-Pad2_ PORT
U14  Net-_U1-Pad11_ Net-_U14-Pad2_ adc_bridge_1
U16  Net-_U14-Pad2_ Net-_U16-Pad2_ d_inverter
U18  Net-_U16-Pad2_ Net-_M5-Pad1_ dac_bridge_1
M5  Net-_M5-Pad1_ Net-_M1-Pad2_ Net-_M5-Pad3_ Net-_M5-Pad3_ eSim_MOS_N
U15  Net-_U1-Pad13_ Net-_U15-Pad2_ adc_bridge_1
U17  Net-_U15-Pad2_ Net-_U17-Pad2_ d_inverter
U19  Net-_U17-Pad2_ Net-_M6-Pad1_ dac_bridge_1
M6  Net-_M6-Pad1_ Net-_M1-Pad2_ Net-_M6-Pad3_ Net-_M6-Pad3_ eSim_MOS_N

.end
